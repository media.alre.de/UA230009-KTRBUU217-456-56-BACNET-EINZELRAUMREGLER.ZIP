Properties of the parts of a building model (IFC2X3)

# File
Description: BACnet Raumregler, UP, 230 VAC, Abdeckung 55 x 55 mm, reinweiß, matt, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: UA230009, BACnet Raumregler, UP, 230 VAC, Abdeckung 55 x 55 mm, reinweiß, matt
In: Raum
Description: Der alre BACnet Einzelraumregler mit grafischem Display wurde speziell für den zeitabhängigen Heiz- und Kühlbetrieb in 2- oder 4-Rohr-Systemen entwickelt. Der Regler kann in vielfältigen Bereichen eingesetzt und angewendet werden, wie zum Beispiel im Hotel, Wohn-, Büro- und Geschäftsräumen sowie in Krankenhäusern und Schulen. Das Gerät besitzt zwei Ein- und drei Ausgänge. Zwei der Ausgänge schalten Relais, die jeweils bis zu 5 Stellantriebe ansprechen können. Der dritte Ausgang ist analog ausgeführt (0–10 V) und kann z. B. für die EC-Lüftersteuerung verwendet werden. Einer der beiden Eingänge dient zur BACnet-Kommunikation, der andere ist konfigurierbar für den Anschluss von Sensoren z. B. für Temperatur oder Taupunkt. Über BACnet können Fenster oder Präsenzkontakte verbunden werden.Passend in alle gängigen Schalterprogramme. Der alre BACnet-Einzelraumregler wird in der Unterputzdose montiert. Das Gehäuse passt exakt in die Designrahmen der Größen 50 x 50 mm, 55 x 55 mm und 60 x 60 mm aus den Flächenschalterprogrammen namhafter Hersteller wie z. B. Berker, Busch-Jaeger, Gira, Jung, Merten, Peha, Hager oder Feller (CH). Sonderfarben für Projekte auf Anfrage.Die Kommunikation erfolgt mittels BACnet gemäß DIN EN ISO 16484-5 mit dem Netzwerkprotokoll BACnet MS/TP. Damit ist der Raumregler mit allen gängigen Systemen der Gebäudeautomation kompatibel. Der Regler entspricht dem BACnet-Profil “B-AAC“ (BACnet Advanced Application Controller) und ist somit weit mehr als ein einfacher Sollwertgeber. Im Unterschied zu anderen Feldbusschnittstellen wie z. B. LON oder KNX kommt die BACnet-Schnittstelle ohne zusätzliches Gateway zur Umsetzung und Kommunikation mit der Managementebene aus. Das spart Kosten, denn zur Inbetriebnahme des Systems werden keine Servicetechniker mit unterschiedlichen Qualifikationen benötigt. Eine weitere Kosteneinsparung gegenüber verteilten Lösungen bringt die Verbindung von Raumbediengerät und Einzelraumregler in einem Gerät.Mit den vordefinierten Applikationen sind vielfältige Anwendungen für Raumtemperierungen in der Raumautomation abgedeckt.Der BACnet Raumregler wurde mit dem BTL Zertifikat für die Einhaltung des BACnet Standard ISO 16484-5 ausgezeichnet, der mittels BTL-Konformitätstest nachgewiesen wurde.; Classification: EC001101 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: UA230009; ModelLabel: KTRBUu217.456#56; GlobalTradeItemNumber: 4050528075840; ProductURL: https://alre.de/produkt_UA230009
Pset_Specification - NominalLength: 0.071 m; NominalWidth: 0.071 m; NominalDepth: 0.046 m; NetWeight: 0.135
Pset_ALRE_ETIM_Properties - Montageart: Unterputz; Zusammenstellung: Basiselement mit zentraler Abdeckplatte; Farbe: weiß; Oberflächenschutz: unbehandelt; Mit Display: yes; Werkstoffgüte: Thermoplast; Mit Busankopplung: yes; Werkstoff: Kunststoff; Andere Bussysteme: sonstige; Mit Diebstahl-/Demontageschutz: no; Manuelle Sollwertverstellung: yes; Parallel-Betrieb möglich: yes; RAL-Nummer (ähnlich): 9010; Schutzart (IP): IP30; Mit LED-Anzeige: no; Ausführung der Oberfläche: matt; Mit Vor-Ort Bedienung: yes; Bussystem KNX Secure: no; Bussystem KNX Secure-RF (Funk): no; ETIM-Klasse: EC001101; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-UA230009.pdf
